## esp_idf_verzija/components/rtc/Kconfig
```kconfig
menu "RTC Configuration"

config RTC_ENABLED
    bool "Enable RTC driver"
    default y

endmenu
```
